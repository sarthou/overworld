Commit message: [pr2 urdf] fix r_forearm_cam_optical_frame link

File: models/pr2.urdf (robot description, URDF)
Before this commit: robot pr2, 88 links, 87 joints
Links:
- link r_forearm_cam_optical_frame: mass None -> 0.01
